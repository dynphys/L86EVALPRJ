# Keil uVision project Soft.uvprojx, settings and files
target Soft (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Soft
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xE
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32L1xx_HAL_Driver/Inc;     ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Include;     ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash.c
  group Application/User
    ../Src/: stm32l1xx_it.c main.c stm32l1xx_hal_msp.c pmtk_driver.c pmtk_hw_config.c misc.c
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
software components: CMSIS:CORE 4.1.0
